# IAR project SMG_Display.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: C:\Users\acer-pc\Desktop\接收显示\软件\Stm8sComFile\stm8lib\inc; ..; $PROJ_DIR$; C:\Users\acer-pc\Desktop\接收显示; C:\Users\acer-pc\Desktop\接收显示\软件
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
