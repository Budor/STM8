# IAR project Game_snake.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: Device\KEY; Hstm8; Device\JLX12864; library\inc; ; C:\Users\acer-pc\Desktop\iar stm8 project\library\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group device
    Device/JLX12864/: jlx12864.c
    Device/KEY/: key.c
  group inc
    library/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_tim4.h
  group src
    library/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim4.c
  group user
    ./: main.c snake.c stm8s_it.c
