# IAR project testDemo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: include; Stm8s_Lib\stm8lib\inc; Stm8s_Lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: testDemo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    source/: delay.c stm8s_it.c
    ./: main.c
  group Periph
    source/: gpio.c spi.c timer.c xn297l.c
  group Stm8sLib
    Stm8s_Lib/stm8lib/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
